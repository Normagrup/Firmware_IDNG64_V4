# Keil uVision project IO_Toggle.uvprojx, settings and files
target IO_Toggle (5060528::V5.06 update 5 (build 528)::.\5.06)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IO_Toggle +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F0-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT5: ROM 0x8001000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c0 size 0x1f40
  group User
    ../: stm32f0xx_it.c m25p.c main.c m25p.h macros.h spi2.h system_stm32f0xx.c spi2.c daliAddressing.c daliAddressing.h dali.c daliTransceiver.c daliTransceiver.h dali.h spi1.h daliLoop.c spi1.c daliLoop.h polling.c config.h ethFramming.c ethFramming.h ethTransceiver.c config.c ethTransceiver.h board.c rtcc.c board.h rtcc.h normalink.c normaLink62386P102.c normaLinkCfgInfoPasarela.c normaLinkSingleLoop.c normaLinkCmdPasarela.c botonera.c historico.c normaLink62386P202.c test.c temp.c normalink.h ethPing.c fallos.c webserver.c wdt.c normaLinkDaliUtils.c polling.h historico.h daliUtils.h fallos.h daliUtils.c normaLinkSingleLoop.h wdt.h normaLinkDaliUtils.h normaLinkCmdPasarela.h normaLinkCfgInfoPasarela.h normaLink62386P202.h normaLink62386P102.h temp.h test.h systick.c systick.h storage.c storage.h sensors.h interfaces.c interfaces.h normaLinkSensores.c sensores.c sensores.h daliSensores.c daliSensores.h normaLinkSensores.h utils.c utils.h sensorScanning.c sensorScanning.h embeddedBootloader.c embeddedBootloader.h dADSA.c dALS.c dANI.c dAPSA.c dAQCGL.c dAQDTL.c dASE.c dASRA.c qSN.c qSN.h sensorStoring.c sensorStoring.h actualLevel.c actualLevel.h iED.c iED.h mainCfg.h historicoTest.c historicoTest.h debug.c debug.h normaLink62386P209.c normaLink62386P209.h
    ../w5100/: w5100.c socket.c socket.h types.h w5100.h
    ../sensoresGrupos/: sensoresGrupos.c sensoresGrupos.h sensoresGruposDetectoresPresencia.c sensoresGruposDetectoresPresencia.h sensoresGruposDetectoresPresencia.txt sensoresGruposPulsadoresAccionBasculante.c sensoresGruposPulsadoresAccionBasculante.h sensoresGruposPulsadoresAccionBasculante.txt sensoresGruposPulsadoresAccionFija.c sensoresGruposPulsadoresAccionFija.h sensoresGruposPulsadoresAccionFija.txt sensoresGruposPulsadoresAccionRegulacion.c sensoresGruposPulsadoresAccionRegulacion.h sensoresGruposPulsadoresAccionRegulacion.txt sensoresGruposPulsadoresAccionTemporizada.c sensoresGruposPulsadoresAccionTemporizada.h sensoresGruposPulsadoresAccionTemporizada.txt sensoresGruposReguladoresLuz.c sensoresGruposReguladoresLuz.h sensoresGruposReguladoresLuz.txt sensoresGruposPulsadoresTW.c sensoresGruposPulsadoresTW.h
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_exti.c stm32f0xx_spi.c stm32f0xx_i2c.c stm32f0xx_rtc.c stm32f0xx_pwr.c stm32f0xx_iwdg.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
software components: CMSIS:CORE 5.4.0
